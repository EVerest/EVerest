# generated by running:
# devtool add https://github.com/EVerest/everest-admin-panel.git --srcbranch main --srcrev 2ff6acd659ea0ce012e42e02d73819130484081f
LICENSE = "0BSD & Apache-2.0 & BSD-2-Clause & BSD-3-Clause & ISC & MIT & Python-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10 \
                    file://node_modules/@babel/helper-string-parser/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@babel/helper-validator-identifier/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@babel/parser/LICENSE;md5=3b324af8e79986f4a5621efa85dd1292 \
                    file://node_modules/@babel/types/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@fontsource/roboto/LICENSE;md5=01a64f52f3fda01d260e2b6757c1f748 \
                    file://node_modules/@highlightjs/vue-plugin/LICENSE;md5=6b77a8a192fe40f7cc1e606f8a7ba5f1 \
                    file://node_modules/@jridgewell/sourcemap-codec/LICENSE;md5=fe86de92781b32da4a26ca689959c26d \
                    file://node_modules/@json-layout/core/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@json-layout/core/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/@json-layout/core/node_modules/linkify-it/LICENSE;md5=e2f6d3a49c2238880c1d728ddc187f7a \
                    file://node_modules/@json-layout/core/node_modules/markdown-it/LICENSE;md5=4323c95e1014fb58368f2d4c2b78064b \
                    file://node_modules/@json-layout/core/node_modules/mdurl/LICENSE;md5=4dd6bce4f4fc62f6f51f603c406c145b \
                    file://node_modules/@json-layout/core/node_modules/uc.micro/LICENSE.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@json-layout/vocabulary/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@koumoul/vjsf/LICENSE;md5=0cf31bb9e2152bcb0ec2adeefcec6469 \
                    file://node_modules/@koumoul/vjsf/node_modules/@json-layout/core/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@koumoul/vjsf/node_modules/@json-layout/vocabulary/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@koumoul/vjsf/node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/@koumoul/vjsf/node_modules/linkify-it/LICENSE;md5=e2f6d3a49c2238880c1d728ddc187f7a \
                    file://node_modules/@koumoul/vjsf/node_modules/markdown-it/LICENSE;md5=4323c95e1014fb58368f2d4c2b78064b \
                    file://node_modules/@koumoul/vjsf/node_modules/mdurl/LICENSE;md5=4dd6bce4f4fc62f6f51f603c406c145b \
                    file://node_modules/@koumoul/vjsf/node_modules/uc.micro/LICENSE.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/@mdi/font/LICENSE;md5=7f104afa30591ec383c5140124c88aef \
                    file://node_modules/@rollup/plugin-commonjs/LICENSE;md5=62156287ac5c93a99f7e0d75ad31c2bf \
                    file://node_modules/@rollup/pluginutils/LICENSE;md5=62156287ac5c93a99f7e0d75ad31c2bf \
                    file://node_modules/@types/estree/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/linkify-it/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/markdown-it/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/mdurl/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/web-bluetooth/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@vue/compat/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-core/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-dom/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-sfc/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-ssr/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/reactivity/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/runtime-core/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/runtime-dom/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/server-renderer/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/shared/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vueuse/core/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/@vueuse/metadata/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/@vueuse/shared/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/ajv-errors/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/ajv-formats/LICENSE;md5=b070047241b584db26163b1dca5206e0 \
                    file://node_modules/ajv-i18n/LICENSE;md5=715855234c57d97032971adfc0608a07 \
                    file://node_modules/ajv/LICENSE;md5=5ed8db7ae36f56c8a5cfc218c41ac926 \
                    file://node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/argparse/LICENSE;md5=203a6dbc802ee896020a47161e759642 \
                    file://node_modules/ast-types/LICENSE;md5=446729a9826c1d80e95dab50c7d30639 \
                    file://node_modules/async/LICENSE;md5=73f63c1fa4541b2f2f34d77140ebe89d \
                    file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/chalk/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/commondir/LICENSE;md5=31f6d70a3b756797901b2aff55cc7d7a \
                    file://node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/core-js/LICENSE;md5=9b58c7623dca66a4985604ae0351502c \
                    file://node_modules/csstype/LICENSE;md5=e71640b3d80aa47c69967e588c744bfb \
                    file://node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/ejs/LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57 \
                    file://node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/esprima/LICENSE.BSD;md5=e3c825c932a984958bafbac21e21f984 \
                    file://node_modules/estree-walker/LICENSE;md5=535713f6259158ff4b0d63de5da7f078 \
                    file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/filelist/node_modules/minimatch/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/glob/LICENSE;md5=c66b78639358cd3f497d598618aa7c93 \
                    file://node_modules/glob/node_modules/minimatch/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/has-flag/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/highlight.js/LICENSE;md5=1536cfb4c71fcc69423296231a64c1c4 \
                    file://node_modules/immer/LICENSE;md5=31f7d36ee7fe711a4628d22f779fc5ef \
                    file://node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/jake/node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/jake/node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/just-clone/LICENSE;md5=9a101e543aed27cd8558f6376292442e \
                    file://node_modules/konva/LICENSE;md5=164b7922ad16f823f27788d36136a44b \
                    file://node_modules/linkify-it/LICENSE;md5=e2f6d3a49c2238880c1d728ddc187f7a \
                    file://node_modules/magic-string/LICENSE;md5=17b8fdc59ea5ccf4488260421093f766 \
                    file://node_modules/magicast/LICENSE;md5=b4c5d677d375a378ad97f463accfbce2 \
                    file://node_modules/markdown-it/LICENSE;md5=4323c95e1014fb58368f2d4c2b78064b \
                    file://node_modules/mdurl/LICENSE;md5=4dd6bce4f4fc62f6f51f603c406c145b \
                    file://node_modules/mitt/LICENSE;md5=4ed316158806c1e39b6b6e457c85b10f \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/nanoid/LICENSE;md5=237c21016e56a1ee4475a39fc00d1504 \
                    file://node_modules/notyf/LICENSE.md;md5=ce2fd27755b03c15b9a2faf59d4cb062 \
                    file://node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/picocolors/LICENSE;md5=8aabd5d21f92335888d962fb6ca980f8 \
                    file://node_modules/picomatch/LICENSE;md5=abd0e25891525eb13d5a794f550a6ee4 \
                    file://node_modules/pinia/LICENSE;md5=c6972b63f41e7aa5567e73d7c133fd47 \
                    file://node_modules/postcss/LICENSE;md5=e0ef868fdaaba6859dcbab082c20439b \
                    file://node_modules/punycode.js/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/punycode/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/recast/LICENSE;md5=3a48a43d5f60ffc26b75ceb41c3d5e04 \
                    file://node_modules/require-from-string/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/source-map-js/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/splitpanes/LICENSE;md5=9908168fcd63d59c0294fc0716f0589d \
                    file://node_modules/supports-color/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/tiny-invariant/LICENSE;md5=eb3cc0ef664b9772890bad9afc4c8274 \
                    file://node_modules/to-fast-properties/license;md5=a3b54a26fb11cf7129550e6ffc7807ea \
                    file://node_modules/tslib/CopyrightNotice.txt;md5=cb391e9e435b114c07bee8f6754c4f98 \
                    file://node_modules/tslib/LICENSE.txt;md5=f938d99cba29007eeae26d80a9a4cfa6 \
                    file://node_modules/uc.micro/LICENSE.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/uri-js/LICENSE;md5=3b55dad4a98748003b5b423477713da1 \
                    file://node_modules/vee-validate/LICENSE;md5=776e453114b988e720953109d13f1ba1 \
                    file://node_modules/vue-class-component/LICENSE;md5=761fb17e53b4b87a0507c26d4bd5bfa4 \
                    file://node_modules/vue-demi/LICENSE;md5=4d2312fbab0cb8f620968a69c30b11b8 \
                    file://node_modules/vue-property-decorator/LICENSE;md5=39a26518d5ca1ab24b5c7d7bff548214 \
                    file://node_modules/vue-router/LICENSE;md5=c6972b63f41e7aa5567e73d7c133fd47 \
                    file://node_modules/vue/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/vuetify/LICENSE.md;md5=7bc9752a662af260bad24e8c01e3b47d \
                    file://node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@fontsource/open-sans-condensed/README.md;md5=ae5614fcc5f29064642a61582e030c9c \
                    file://node_modules/filelist/README.md;md5=0ac6536990331f035d4c3b2995031e00 \
                    file://node_modules/is-reference/README.md;md5=1ae863bf798164adb824f7ec768eb094 \
                    file://node_modules/jake/README.md;md5=90aba202619b2a9b4a046973a2a96c99 \
                    file://node_modules/vee-validate/node_modules/type-fest/readme.md;md5=140b5fb52a7590de9d27eba661a38176"

SRC_URI = "https://github.com/EVerest/everest-admin-panel/releases/download/v0.2.0/everest-admin-panel.tar.gz;subdir=${S}/everest-admin-panel \
           npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
          "
SRC_URI[sha256sum] = "d7f1e878306311884fc869f75370391ae0494f6841e24a992245b2a659217263"

FILES:${PN} += "${datadir}/everest/www/*"

do_install() {
    install -d ${D}/usr/share/everest/www
    cp -a --no-preserve=ownership ${S}/everest-admin-panel/* ${D}/usr/share/everest/www/
}

INSANE_SKIP:${PN} += "file-rdeps"

LICENSE:${PN} = "Apache-2.0"
LICENSE:${PN}-babel-helper-string-parser = "MIT"
LICENSE:${PN}-babel-helper-validator-identifier = "MIT"
LICENSE:${PN}-babel-parser = "MIT"
LICENSE:${PN}-babel-types = "MIT"
LICENSE:${PN}-fontsource-open-sans-condensed = "MIT"
LICENSE:${PN}-fontsource-roboto = "Apache-2.0"
LICENSE:${PN}-highlightjs-vue-plugin = "BSD-3-Clause"
LICENSE:${PN}-jridgewell-sourcemap-codec = "MIT"
LICENSE:${PN}-json-layout-core-entities = "BSD-2-Clause"
LICENSE:${PN}-json-layout-core-linkify-it = "MIT"
LICENSE:${PN}-json-layout-core-markdown-it = "MIT"
LICENSE:${PN}-json-layout-core-mdurl = "MIT"
LICENSE:${PN}-json-layout-core-ucmicro = "MIT"
LICENSE:${PN}-json-layout-core = "MIT"
LICENSE:${PN}-json-layout-vocabulary = "MIT"
LICENSE:${PN}-koumoul-vjsf-json-layout-core = "MIT"
LICENSE:${PN}-koumoul-vjsf-json-layout-vocabulary = "MIT"
LICENSE:${PN}-koumoul-vjsf-entities = "BSD-2-Clause"
LICENSE:${PN}-koumoul-vjsf-linkify-it = "MIT"
LICENSE:${PN}-koumoul-vjsf-markdown-it = "MIT"
LICENSE:${PN}-koumoul-vjsf-mdurl = "MIT"
LICENSE:${PN}-koumoul-vjsf-ucmicro = "MIT"
LICENSE:${PN}-koumoul-vjsf = "MIT"
LICENSE:${PN}-mdi-font = "Apache-2.0"
LICENSE:${PN}-rollup-plugin-commonjs = "MIT"
LICENSE:${PN}-rollup-pluginutils = "MIT"
LICENSE:${PN}-types-estree = "MIT"
LICENSE:${PN}-types-linkify-it = "MIT"
LICENSE:${PN}-types-markdown-it = "MIT"
LICENSE:${PN}-types-mdurl = "MIT"
LICENSE:${PN}-types-web-bluetooth = "MIT"
LICENSE:${PN}-vue-compat = "MIT"
LICENSE:${PN}-vue-compiler-core = "MIT"
LICENSE:${PN}-vue-compiler-dom = "MIT"
LICENSE:${PN}-vue-compiler-sfc = "MIT"
LICENSE:${PN}-vue-compiler-ssr = "MIT"
LICENSE:${PN}-vue-devtools-api = "MIT"
LICENSE:${PN}-vue-reactivity = "MIT"
LICENSE:${PN}-vue-runtime-core = "MIT"
LICENSE:${PN}-vue-runtime-dom = "MIT"
LICENSE:${PN}-vue-server-renderer = "MIT"
LICENSE:${PN}-vue-shared = "MIT"
LICENSE:${PN}-vueuse-core = "MIT"
LICENSE:${PN}-vueuse-metadata = "MIT"
LICENSE:${PN}-vueuse-shared = "MIT"
LICENSE:${PN}-ajv = "MIT"
LICENSE:${PN}-ajv-errors = "MIT"
LICENSE:${PN}-ajv-formats = "MIT"
LICENSE:${PN}-ajv-i18n = "MIT"
LICENSE:${PN}-ansi-styles = "MIT"
LICENSE:${PN}-argparse = "Python-2.0"
LICENSE:${PN}-ast-types = "MIT"
LICENSE:${PN}-async = "MIT"
LICENSE:${PN}-balanced-match = "MIT"
LICENSE:${PN}-brace-expansion = "MIT"
LICENSE:${PN}-chalk = "MIT"
LICENSE:${PN}-color-convert = "MIT"
LICENSE:${PN}-color-name = "MIT"
LICENSE:${PN}-commondir = "MIT"
LICENSE:${PN}-concat-map = "MIT"
LICENSE:${PN}-core-js = "MIT"
LICENSE:${PN}-csstype = "MIT"
LICENSE:${PN}-debug = "MIT"
LICENSE:${PN}-ejs = "Apache-2.0"
LICENSE:${PN}-entities = "BSD-2-Clause"
LICENSE:${PN}-esprima = "BSD-2-Clause"
LICENSE:${PN}-estree-walker = "MIT"
LICENSE:${PN}-fast-deep-equal = "MIT"
LICENSE:${PN}-filelist-minimatch = "ISC"
LICENSE:${PN}-filelist = "Apache-2.0"
LICENSE:${PN}-fsrealpath = "ISC"
LICENSE:${PN}-glob-minimatch = "ISC"
LICENSE:${PN}-glob = "ISC"
LICENSE:${PN}-has-flag = "MIT"
LICENSE:${PN}-highlightjs = "BSD-3-Clause"
LICENSE:${PN}-immer = "MIT"
LICENSE:${PN}-inflight = "ISC"
LICENSE:${PN}-inherits = "ISC"
LICENSE:${PN}-is-reference = "MIT"
LICENSE:${PN}-jake-brace-expansion = "MIT"
LICENSE:${PN}-jake-minimatch = "ISC"
LICENSE:${PN}-jake = "Apache-2.0"
LICENSE:${PN}-js-yaml = "MIT"
LICENSE:${PN}-json-schema-traverse = "MIT"
LICENSE:${PN}-just-clone = "MIT"
LICENSE:${PN}-konva = "MIT"
LICENSE:${PN}-linkify-it = "MIT"
LICENSE:${PN}-magic-string = "MIT"
LICENSE:${PN}-magicast = "MIT"
LICENSE:${PN}-markdown-it = "MIT"
LICENSE:${PN}-mdurl = "MIT"
LICENSE:${PN}-mitt = "MIT"
LICENSE:${PN}-ms = "MIT"
LICENSE:${PN}-nanoid = "MIT"
LICENSE:${PN}-notyf = "MIT"
LICENSE:${PN}-once = "ISC"
LICENSE:${PN}-picocolors = "ISC"
LICENSE:${PN}-picomatch = "MIT"
LICENSE:${PN}-pinia = "MIT"
LICENSE:${PN}-postcss = "MIT"
LICENSE:${PN}-punycode = "MIT"
LICENSE:${PN}-punycodejs = "MIT"
LICENSE:${PN}-recast = "MIT"
LICENSE:${PN}-require-from-string = "MIT"
LICENSE:${PN}-source-map = "BSD-3-Clause"
LICENSE:${PN}-source-map-js = "BSD-3-Clause"
LICENSE:${PN}-splitpanes = "MIT"
LICENSE:${PN}-supports-color = "MIT"
LICENSE:${PN}-tiny-invariant = "MIT"
LICENSE:${PN}-to-fast-properties = "MIT"
LICENSE:${PN}-tslib = "0BSD"
LICENSE:${PN}-ucmicro = "MIT"
LICENSE:${PN}-uri-js = "BSD-2-Clause"
LICENSE:${PN}-vee-validate-type-fest = "MIT | CC0-1.0"
LICENSE:${PN}-vee-validate = "MIT"
LICENSE:${PN}-vue = "MIT"
LICENSE:${PN}-vue-class-component = "MIT"
LICENSE:${PN}-vue-demi = "MIT"
LICENSE:${PN}-vue-property-decorator = "MIT"
LICENSE:${PN}-vue-router = "MIT"
LICENSE:${PN}-vuetify = "MIT"
LICENSE:${PN}-wrappy = "ISC"
