FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://openssl-3.5-feat-updates-to-support-status_request_v2.patch"
